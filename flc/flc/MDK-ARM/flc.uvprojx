# Keil uVision project flc.uvprojx, settings and files
target flc (6180000::V6.18::ARMCLANG)
  device: STM32L471ZETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: flc +hex
  AfterMake: ..\..\..\tools\hex2bin\hex2bin.exe  .\flc\flc.hex out=..\..\flc.dfu fill=255 release dfu no_dfx
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=6
  c define: xxPCB_TEST,HAL_WDT_ENABLE,USE_RTC,PLF_OS=PLF_OS_EVOS,NVM_ACCESS=NVM_ACCESS_ADDRESS,USE_HAL_DRIVER,STM32L471xx,USE_FULL_LL_DRIVER
  c misc: -Wall -Wextra -Wno-unused-parameter -Wno-char-subscripts -Wshadow -Wnon-virtual-dtor -Wold-style-cast -Wunused -Woverloaded-virtual -Wpedantic -Wnull-dereference -Wdouble-promotion
  c include: ..\..\..\flc;                 ..\..\..\common;                 ..\..\..\common\plf\json\jansson-2.12;                 ..\..\..\common\net\modem_sim7070;                 ../Core/Inc;                 ../Drivers/STM32L4xx_HAL_Driver/Inc;                 ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;                 ../Drivers/CMSIS/Device/ST/STM32L4xx/Include;                 ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x3bfc0
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x7fc0
  group app
    ../../../flc/app/: app.c app.h
    ../../app/: dlogger.c dlogger.h flc_cfg.c flc_cfg.h flc_cfg_hw_v1.c flc_def.h
  group shc
    ../../../flc/shc/: shc.c shc.h
    ../../shc/: pump.c pump.h uv_lamp.c uv_lamp.h valve.c valve.h flow_knob.c flow_knob.h hot_supply.c hot_supply.h cold_supply.c cold_supply.h prime_pump.c prime_pump.h
  group cif
    ../../../flc/cif/: cif.c cif.h cloud.h cloud_def.h cloud_texts.c cloud_texts.h
    ../../cif/: cloud_flc.c cloud_flc.h
  group pow
    ../../pow/: pow.h pow.c pow_cycling_support.c
  group sup
    ../../../flc/sup/: sup.c sup.h
    ../../sup/: adc_mux.c adc_mux.h float_switch.c float_switch.h log_sensors.c log_sensors.h pos_sensor.c pos_sensor.h water_sensor.c water_sensor.h user_button.c user_button.h
  group sif
    ../../../flc/sif/: sif.c sif.h sif_menu.c
  group net
    ../../../common/net/rest/: rest.h rest_get.c
    ../../../common/net/modem_sim7070/: modem.c modem.h modem_cli.c modem_mqtt.h modem_mqtt_SIM7070.c modem_net.h modem_net_SIM7070.c modem_power.h modem_power_SIM7070.c modem_ready.h modem_ready_SIM7070.c modem_tcp.h modem_tcp_SIM7070.c modem_fota.h modem_fota_SIM7070.c
  group plf
    ../../../flc/plf/: plf.c
    ../../../common/plf/cli/: cli.c
    ../../../common/plf/crc/: crc16.c
    ../../../common/plf/evos/: evos.c
    ../../../common/plf/fifo/: fifo.c
    ../../../common/plf/heap/: heapx.c
    ../../../common/plf/key/: key.c
    ../../../common/plf/led/: led.c
    ../../../common/plf/nvm/: nvm_fram.c
    ../../../common/plf/trc/: trc.c
    ../../../common/plf/ver/: ver.c
    ../../../common/plf/vtim/: vtim.c
    ../../../common/plf/util/: widechar.c widechar.h
  group plf/blc
    ../../../common/plf/blc/: blc.c blc_crc.c blc_crc.h
  group plf/json
    ../../../common/plf/json/: jsonx.c
    ../../../common/plf/json/jansson-2.12/: dump.c error.c hashtable.c hashtable_seed.c load.c memory.c pack_unpack.c strbuffer.c strconv.c utf.c value.c
  group plf/log
    ../../../common/plf/dlog/: dlog.c dlog.h
    ../../../common/plf/elog/: elog.c elog.h
  group plf/util
    ../../../common/plf/util/: linear_interpolation.c linear_interpolation.h
  group hal
    ../../../flc/hal/: hal.c
    ../../../common/hal/adc/: adc.c
    ../../../common/hal/dflash/: dflash.c
    ../../../common/hal/dio/: dio.c
    ../../../common/hal/fram/: fram_spi_MB85RS16.c
    ../../../common/hal/pwm/: pwm.c
    ../../../common/hal/rtc/: rtc_stm32.c
    ../../../common/hal/wdt/: wdt.c
    ../../../common/hal/uart/: uart_l4.c
  group Application/MDK-ARM
    ./: startup_stm32l471xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32l4xx_it.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_tim.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_ll_utils.c stm32l4xx_ll_exti.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_ll_tim.c stm32l4xx_ll_gpio.c stm32l4xx_ll_dma.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
software components: CMSIS:CORE 5.5.0
