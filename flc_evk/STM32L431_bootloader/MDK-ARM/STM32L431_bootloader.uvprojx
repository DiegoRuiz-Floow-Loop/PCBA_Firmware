# Keil uVision project STM32L431_bootloader.uvprojx, settings and files
target STM32L431_bootloader (6160000::V6.16::ARMCLANG)
  device: STM32L431VCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: flc_evk_bootloader +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=6 v6Lto=1
  c define: EVK,BOOTLOADER,HAL_WDT_ENABLE,PLF_OS=PLF_OS_EVOS,NVM_ACCESS=NVM_ACCESS_ADDRESS,USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32L431xx
  c misc: -Wall -Wextra -Wno-unused-parameter -Wno-char-subscripts -Wshadow -Wnon-virtual-dtor -Wold-style-cast -Wcast-align -Wunused -Woverloaded-virtual -Wpedantic -Wnull-dereference -Wdouble-promotion -Wformat=2
  c include: ../Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include; ../../../flc; ../../../common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group bapp
    ../../../common/bapp/: bapp.c bapp.h bapp_menu.c bapp_util.c
  group plf
    ../../../flc/plf/: plf.c
    ../../../common/plf/evos/: evos.c evos.h
    ../../../common/plf/sio/: sio.c sio.h
    ../../../common/plf/crc/: crc16.c crc16.h
    ../../../common/plf/led/: led.c led.h
    ../../../common/plf/fifo/: fifo.c fifo.h
  group plf/blc
    ../../../common/plf/blc/: blc.c blc.h blc_def.h bootjump_stm32.s
  group hal
    ../../../flc/hal/: hal.c
    ../../../common/hal/uart/: uart_l4.c
    ../../../common/hal/dflash/: dflash.c
    ../../../common/hal/dio/: dio.c
    ../../../common/hal/wdt/: wdt.c
    ../../../common/hal/pflash/: pflash_stm32l4.c
  group Application/MDK-ARM
    ./: startup_stm32l431xx.s
  group Application/User
    ../Src/: main.c stm32l4xx_it.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_tim.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_ll_utils.c stm32l4xx_ll_exti.c stm32l4xx_ll_gpio.c stm32l4xx_hal_iwdg.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
software components: CMSIS:CORE 5.4.0
